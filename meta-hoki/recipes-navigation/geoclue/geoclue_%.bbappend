RDEPENDS:${PN}:append:hoki = " geoclue-provider-libqmi "
