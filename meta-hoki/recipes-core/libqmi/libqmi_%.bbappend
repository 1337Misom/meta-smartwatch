PACKAGECONFIG:append = " qrtr"
